# Keil uVision project led.uvprojx, settings and files
target Lesson1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: .\stm32f10x_fwlib\inc;.\stm32f10x_fwlib\src;.\baselib;.\system;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group baselib
    ./baselib/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_cl.s
  group stm32f10x_fwlib
    ./stm32f10x_fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ./user/: main.c main.h
  group system
    ./system/: delay.c delay.h
